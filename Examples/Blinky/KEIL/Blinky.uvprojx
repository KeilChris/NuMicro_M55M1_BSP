# Keil uVision project Blinky.uvprojx, settings and files
target Blinky (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: Blinky
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\RTE\Device\M55M1H2LJAE\M55M1.scf
  group User
    ../: main.c
software components: CMSIS:CORE 6.1.0, CMSIS Driver:Common:M55M1_M5531 1.0.0, CMSIS Driver:VIO:M55M1 1.0.0, Device:Startup 1.0.0, Device:StdDriver:CLK 1.0.0, Device:StdDriver:GPIO 1.0.0, Device:StdDriver:LPPDMA 1.0.0, Device:StdDriver:PDMA 1.0.0, Device:StdDriver:Retarget 1.0.0, Device:StdDriver:SYS 1.0.0, Device:StdDriver:UART 1.0.0
