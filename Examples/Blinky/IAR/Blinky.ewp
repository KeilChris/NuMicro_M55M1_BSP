# IAR project Blinky.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M55M1x2LJAE series Nuvoton M55M1x2LJAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$_$CONFIG_NAME$.bin
  ILINK.IlinkOutputFile: Blinky.out
  ILINK.IlinkIcfFile: ..\RTE\Device\M55M1H2LJAE\M55M1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/CMSIS Driver.Common M55M1_M5531
    ${CMSIS_PACK_PATH_Nuvoton#NuMicroM55_DFP#3.1.3}$/Library/CMSIS/Driver/Source/: drv_lppdma.c drv_pdma.c misc.c
    ../RTE/CMSIS_Driver/M55M1H2LJAE/: RTE_Device.h
  group CMSIS-Pack/Device.StdDriver LPPDMA
    ${CMSIS_PACK_PATH_Nuvoton#NuMicroM55_DFP#3.1.3}$/Library/StdDriver/src/: lppdma.c
  group CMSIS-Pack/Device.StdDriver PDMA
    ${CMSIS_PACK_PATH_Nuvoton#NuMicroM55_DFP#3.1.3}$/Library/StdDriver/src/: pdma.c
  group CMSIS-Pack/CMSIS Driver.VIO M55M1
    ${CMSIS_PACK_PATH_Nuvoton#NuMicroM55_DFP#3.1.3}$/Library/CMSIS/Driver/VIO/Source/: vio_NuMaker-M55M1.c
  group CMSIS-Pack/Device Startup
    ../RTE/Device/M55M1H2LJAE/: M55M1.icf startup_M55M1.c system_M55M1.c
  group CMSIS-Pack/Device.StdDriver CLK
    ${CMSIS_PACK_PATH_Nuvoton#NuMicroM55_DFP#3.1.3}$/Library/StdDriver/src/: clk.c
  group CMSIS-Pack/Device.StdDriver GPIO
    ${CMSIS_PACK_PATH_Nuvoton#NuMicroM55_DFP#3.1.3}$/Library/StdDriver/src/: gpio.c
  group CMSIS-Pack/Device.StdDriver Retarget
    ${CMSIS_PACK_PATH_Nuvoton#NuMicroM55_DFP#3.1.3}$/Library/StdDriver/src/: retarget.c
  group CMSIS-Pack/Device.StdDriver SYS
    ${CMSIS_PACK_PATH_Nuvoton#NuMicroM55_DFP#3.1.3}$/Library/StdDriver/src/: sys.c
  group CMSIS-Pack/Device.StdDriver UART
    ${CMSIS_PACK_PATH_Nuvoton#NuMicroM55_DFP#3.1.3}$/Library/StdDriver/src/: uart.c
